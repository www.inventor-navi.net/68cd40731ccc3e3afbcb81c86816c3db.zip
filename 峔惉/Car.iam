# Autodesk Inventor assembly: TOP
## iProperties
Created: 2007-12
Part Number: TOP
Document SubType Name: Assembly
Designer: UJA2299
Author: UJA2299
