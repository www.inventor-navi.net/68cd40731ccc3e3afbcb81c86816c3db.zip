# Autodesk Inventor assembly: Sus-R
## iProperties
Created: 2007-12
Part Number: Sus-R
Document SubType Name: Assembly
Designer: UJA2299
Author: UJA2299
