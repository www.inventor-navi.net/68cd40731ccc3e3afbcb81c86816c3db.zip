# Autodesk Inventor part: Body
## iProperties
Created: 2008-01
Part Number: Body
Document SubType Name: Modeling
Designer: t-ikumi
Density: 1 g/cm^3
Author: t-ikumi
