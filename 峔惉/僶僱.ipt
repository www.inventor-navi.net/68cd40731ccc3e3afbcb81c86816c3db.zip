# Autodesk Inventor part: バネ
## iProperties
Created: 2008-02
Part Number: バネ
Document SubType Name: Modeling
Designer: t-ikumi
Density: 1 g/cm^3
Author: t-ikumi
## Feature names
1. コイル1
