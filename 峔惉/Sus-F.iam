# Autodesk Inventor assembly: Sus-F
## iProperties
Created: 2007-12
Part Number: Sus-F
Document SubType Name: Assembly
Designer: UJA2299
Author: UJA2299
