# Autodesk Inventor assembly: CAR移動TOP
## iProperties
Created: 2008-03
Part Number: CAR移動TOP
Document SubType Name: Assembly
Designer: t-ikumi
Author: t-ikumi
